# Keil uVision project my_stm32.uvproj, settings and files
target M3_boot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: my_stm32 +hex
  AfterMake: fromelf --bin -o ..\..\bin\M3_boot.bin .\Obj\my_stm32.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\lib\CMSIS\Core;.\lib\STM32F10x_StdPeriph_Driver\inc;.\uC_CPU\inc;.\uCOS-II\inc;.\APP_inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\my_stm32.scat
  link misc: --entry Reset_Handler
  group boot
    ./App/: startup_f103x.s Stm32f103_it.c
  group app
    ./App/: main.c SysTick.c des.c Boot_hal.c System_var.c ABA.c Command_Process.c DK_RFM69H.c spi.c Timer.c M3_315.c
  group core
    ./lib/CMSIS/Core/: core_cm3.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group uc-cpu
    ./uC_CPU/src/: cpu_a.asm
